# Keil uVision project banklocker_security.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: banklocker_security +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s projectmain.c lcd.c delay.c kpm2.c ext_int.c device.c i2c.c i2c_eeprom.c pin_connect_block.c
  group Finger print
    ./: uart0.c R305.c
